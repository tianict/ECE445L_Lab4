# Keil uVision project ST7735.uvprojx, settings and files
target ST7735 (6150000::V6.15::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ST7735 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..\..\ExtendedDrivers;..\..\..\..\TM4C123Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: ST7735Example.c
    ../../../lib/ST7735/: ST7735.c Font.c
    ../../../lib/BMP/: BMP.c
    ../../../../TM4C123Drivers/inc/: startup.s
    ../../../../TM4C123Drivers/lib/SSI/: SSI.c
    ../../../../TM4C123Drivers/lib/GPIO/: GPIO.c
    ../../../../TM4C123Drivers/lib/FaultHandler/: FaultHandler.c
    ../../../../TM4C123Drivers/lib/PLL/: PLL.c
    ../../../../TM4C123Drivers/lib/Timer/: Timer.c
software components: CMSIS:CORE 5.4.0
